# Keil uVision project stm32f301_video.uvprojx, settings and files
target stm32f301_video (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F301K8Ux STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f301_video +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F301x8,USE_HAL_DRIVER,USE_STM32F3_DISCO
  c include: ..\st_lib\STM32F3xx_HAL_Driver\Inc;..\st_lib\CMSIS\Device\ST\STM32F3xx\Include;..\st_lib\CMSIS\Core\Include;..\main;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group main
    ../main/: main.c stm32f3xx_it.c system_stm32f3xx.c startup_stm32f301x8.s config.h
  group st_lib\STM32F3xx_HAL_Driver\Src
    ../st_lib/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_gpio.c stm32f3xx_hal_uart.c stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_rcc.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
  group app
    ../app/: debug.c watchdog.c rssi_signal_ctrl.c sync_head_ctrl.c pin30_ctrl.c pin12_ctrl.c pin25_ctrl.c pin24_ctrl.c pin27_ctrl.c systick.c pwm_ctrl.c
  group readme
    ../readme/: readme.txt
